# Repository c3n3/desg-of-senio

File README.md:

# desg-of-senio
This is the repo for all the things of senior design

## Arduino add esp32 support
https://circuitdigest.com/microcontroller-projects/programming-esp32-with-arduino-ide

## Dual core exp32
https://randomnerdtutorials.com/esp32-dual-core-arduino-ide/

test

## KiCad design Kicad/3.28.2022/Kicad/Circuit V2/circuit/final project circ 1/final project circ 1.kicad_pcb

Board: 2 copper layers, 85 parts (0 on the bottom side), 75 nets.

Parts:
A1, A2: Pololu_Breakout_DRV8825; Pololu_Breakout-16_15.2x20.3mm
C1: 100p; C_1210_3225Metric
C2: 4.7n; C_0603_1608Metric
C3, C4, C6: 0.1u; C_1206_3216Metric
C5: 1n; C_1210_3225Metric
C7: 4.7u; C_0805_2012Metric
C8, C9, C10: 100u; CP_Radial_D6.3mm_P2.50mm
C11, C12: 100u; CP_Radial_D16.0mm_P7.50mm
C13: 1u; CP_Radial_D6.3mm_P2.50mm
C14: 4.7uF; C_0603_1608Metric
C15, C20: 0.1uF; C_1206_3216Metric
C16, C17: 0.1uF/50v; C_1206_3216Metric
C18: 22uF; CP_EIA-3528-21_Kemet-B
C21: 22uF/10V; CP_EIA-3528-21_Kemet-B
C22: 0.1uF/50V; C_1206_3216Metric
C23: 100 nf; CP_EIA-7343-40_Kemet-Y
D1, D2, D3, D4: 1N4004; D_DO-41_SOD81_P10.16mm_Horizontal
D5: BZT52Bxx; D_DO-41_SOD81_P10.16mm_Horizontal
D6: PMEG3005EJ; D_SOD-323F
D7: LED; LED_1206_3216Metric
D9: S1DTR; SMAJ140CA
J1: USB_B_Micro; USB_Micro-B_Amphenol_10118194_Horizontal
J3, J4, J7: Conn_01x04_Female; PinSocket_1x04_P2.54mm_Vertical
J5, J6: Conn_01x03_Female; encoder_out
J8, J9, J10, J11: Conn_01x02_Female; button
L1: 33u; MPXV1D1740L330
PWM1, PWM2: Conn_01x02_Male; PinSocket_1x02_P2.54mm_Vertical
Q1, Q2, Q3: FDD770N15A; TO-252-3_TabPin2
Q4, Q5: SS8050-G
Q6: 2SC1945; TO-220-3_Vertical
R1, R6, R7, R14: 10k; R_1210_3225Metric
R2: 30.1k; R_0805_2012Metric
R3: 36.5k; R_0805_2012Metric
R4: 511k; R_0603_1608Metric
R5: 6m; R_0805_2012Metric
R8: 10k; R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal
R9: 22.1k; R_0805_2012Metric
R10: 47.5k; R_1206_3216Metric
R11, R12: 2k; R_0805_2012Metric
R13, R15: 0; R_0805_2012Metric
R16, R17, R18, R19, R20, R21, R22, R23, R24: 10K; R_1210_3225Metric
SW1, SW2: SW_Push; button
U1: LTC3895IFE
U2: CP2102N-A01-GQFN28; QFN-28-1EP_5x5mm_P0.5mm_EP3.35x3.35mm
U3, U5: AZ1117-3.3; TO-252-3_TabPin2
U4: USBLC6-4; USBLC6-4SC6
U6: ESP32-WROOM-32D; ESP32-WROOM-32
U7: SRD-S-112DM; SRD-S-112DM(F-11) Relay
U8: L2293QTR

Connections:
3.3V_USBREG: A1.13, A1.14, A2.13, A2.14, C21.1, C22.1, C23.1, R17.2, R18.1, R19.2, R20.1, R21.2, R22.2, R23.2, R24.2, U3.2, U5.2, U6.2, U8.27
12v: A1.8, A2.8, C5.1, C8.2, C9.2, C10.2, D9.2, R4.1, R5.2, U1.4, U1.32, U8.12, U8.13
+VDC: C12.2, Q1.2, Q3.2, Q6.2, U1.30, U1.34, U7.2
But1: J8.1, R21.1, U6.36
But2: J9.1, R22.1, U6.37
But3: J10.1, R23.1, U6.10
But4: J11.1, R24.1, U6.13
D+: J1.3, U2.4, U4.3
D-: J1.2, U2.5, U4.1
DTR: Q5.2, R7.1
EN: C17.1, C20.1, Q4.3, R16.2, SW2.2, U6.3
EN1: U6.23, U8.29
EN2: U6.27, U8.14
Ex2: J7.2, U6.24
Ex3: J7.3, U6.26
Ex4: J7.4, U6.29
GND: A1.1, A1.7, A2.1, A2.7, C4.2, C14.2, C15.2, C16.2, C17.2, C18.1, C20.2, C21.2, C22.2, C23.2, D7.1, J1.5, J5.2, J6.2, J8.2, J9.2, J10.2, J11.2, R10.2, R14.1, SW1.1, SW2.1, U2.3, U2.29, U3.1, U4.2, U5.1, U6.1, U6.15, U6.38, U6.39, U7.4, U8.9, U8.17, U8.24, U8.28, U8.32
GND1: C1.2, C2.2, C3.2, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, D1.2, D2.2, D5.2, Q2.3, R2.2, R3.2, U1.1, U1.9, U1.12, U1.15, U1.19, U1.39, U7.1
IN1: U6.28, U8.30
IN2: U6.30, U8.11
IN3: U6.31, U8.15
IN4: U6.33, U8.26
IO0: C16.1, Q5.3, SW1.2
LINE: D1.1, D3.2
NEUT: D2.1, D4.2
unnamed: A1.3, J3.2
unnamed: A1.4, J3.1
unnamed: A1.5, J3.3
unnamed: A1.6, J3.4
unnamed: A1.15, U6.14
unnamed: A1.16, U6.16
unnamed: A2.3, J4.2
unnamed: A2.4, J4.1
unnamed: A2.5, J4.3
unnamed: A2.6, J4.4
unnamed: A2.15, U6.11
unnamed: A2.16, U6.12
unnamed: C1.1, R1.2
unnamed: C2.1, R1.1, U1.7
unnamed: C3.1, U1.8, U1.10, U1.38
unnamed: C4.1, U1.5
unnamed: C5.2, L1.1, R5.1, U1.3
unnamed: C6.1, L1.2, Q2.2, Q3.3, U1.21
unnamed: C6.2, U1.22
unnamed: C7.2, Q1.3, U1.26
unnamed: C11.2, D3.1, D4.1, Q6.3, R8.2
unnamed: C13.2, D5.1, Q6.1, R8.1
unnamed: C18.2, D6.1, R12.2, U3.3
unnamed: D7.2, R12.1
unnamed: D9.1, U5.3
unnamed: J5.1, R19.1, U6.8
unnamed: J5.3, R20.2, U6.9
unnamed: J6.1, R17.1, U6.6
unnamed: J6.3, R18.2, U6.7
unnamed: PWM1.1, U8.25
unnamed: PWM1.2, U8.16
unnamed: PWM2.1, U8.10
unnamed: PWM2.2, U8.31
unnamed: Q1.1, U1.28
unnamed: Q2.1, U1.24
unnamed: Q3.1, U1.20
unnamed: Q4.1, R7.2
unnamed: Q5.1, R6.2
unnamed: R2.1, U1.17
unnamed: R3.1, R4.2, U1.6
unnamed: R9.1, R10.1, U2.8
unnamed: R11.2, U2.9
unnamed: R13.2, U2.25
unnamed: R14.2, U2.11
unnamed: R15.1, U2.26
RTS: Q4.2, R6.1
RXD0: R13.1, U6.34
TXD0: R15.2, U6.35
VB: D6.2, J1.1, R9.2, U4.5
VDD33: C14.1, C15.1, R11.1, R16.1, U2.6, U2.7

## KiCad design Kicad/final/final/final.kicad_pcb

Parts:
A12, A13: Conn_01x03_Female; encoder_out
B2, B3: Conn_01x02_Female; button_out
C1: 1uF; 5.5mm_cap
C2: 10uF; CP_Radial_D4.0mm_P1.50mm
D1, D5, D6: D; D_A-405_P7.62mm_Horizontal
D2: SMBJ20A
D3: CLM3C-MKW-CWAXB133
D4: B1931UD--05D000314U1930
D7: THT_LED; PinHeader_1x02_P2.54mm_Vertical
E10, E11: Conn_01x03_Female; encoder_out
F1: Fuse; fuse
J1: 54-00164
J2: Backup_If_Motor_driver_dont_work; PinHeader_1x06_P2.54mm_Vertical
J3: AC_IN; AC
J4: AC_OUT; AC
K1: SRD-S-112DM(F-11); Relay_SPST_SANYOU_SRD_Series_Form_A
PWM5, PWM6: Conn_01x02_Female; button_out
PW_SW14, PW_SW15: SW; button_out
Q1, Q2, Q3: PJE8408_R1_00001
R1: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R2, R12, R13: 10k; RNCP0805FTD10K0
R3: 43F3R0E; R_Axial_DIN0614_L14.3mm_D5.7mm_P20.32mm_Horizontal
R4: 440; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R5: 600; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R6, R7, R8, R9, R10, R11: 10K; RNCP0805FTD10K0
R14: 660; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
RV1: B72214S0351K101; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
S7, S8, S9: Conn_01x04_Male; stepper_out
SD1, SD2, SD3: A4988
SW16, SW17, SW18, SW19: SW; button_out
SW_V14_3.3, SW_V15_3.3: 3.3V; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
SW_V14_5, SW_V15_5: 5V; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
SW_V14_12, SW_V15_12: 12V; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
U1: SN74LVC2G06DCKR; SOT-363_SC-70-6_Handsoldering
U2: L2293QTR
U3: PSK-20D-12; PSK-20D
U4: SN74AHCT595N; SN74HC595N
U5: esp32_dev; ESP32_dev_board
U6, U7: EE2-5NU; KEM
VREG1: ZLDO1117G50TA

Connections:
3.3V: A12.1, A13.1, R6.2, R7.2, R8.2, R9.2, R10.2, R11.2, SD1.15 (VDD), SD2.15 (VDD), SD3.15 (VDD), SW_V14_3.3.1, SW_V15_3.3.1, U1.5 (VCC), U2.27 (VSS)
5V: D5.1, D6.1, R5.1, SW_V14_5.1, SW_V15_5.1, U4.10 (~SRCLR), U4.16 (VCC), U5.19 (VIN), U6.1 (L+), U7.1 (L+), VREG1.2 (Vout)
12V: C1.1, C2.1, D1.1, D2.2 (A), J1.1, K1.5, R4.1, SD1.9 (VMOT), SD2.9 (VMOT), SD3.9 (VMOT), SW_V14_12.1, SW_V15_12.1, U2.12 (VS), U2.13 (VS), U3.4 (+V), VREG1.3 (Vin)
AC_L: F1.2, J3.1, K1.3
AC_L_OUT: J4.1, K1.1
AC_N: J3.2, J4.2, RV1.2, U3.2 (AC_N)
EN: U5.2 (EN)
ESP_3.3V: U5.1 (3.3V)
G0: U5.33 (G0/ADC11)
G1: U5.23 (G1/TX0)
G2: U5.34 (G2/ADC12)
G3: U5.24 (G3/RX0)
G4: E10.1, R6.1, U5.32 (G4/ADC10)
G5: E10.3, R7.1, U5.29 (G5/VSPI_SS)
G6: U5.38 (G6/CLK)
G7: U5.37 (G7/SD0)
G8: U5.36 (G8/SD1)
G9: U5.16 (G9/SD2)
G10: U5.17 (G10/SD3)
G11: U5.18 (G11/CMD)
G12: U5.13 (G12)
G13: U4.14 (SER), U5.15 (G13)
G14: A12.2, U5.12 (G14)
G15: A13.2, U5.35 (G15/ADC13)
G16: U4.12 (RCLK), U5.31 (G16)
G17: U4.11 (SRCLK), U5.30 (G17)
G18: J2.6, U2.14 (ENABLE2), U5.28 (G18/VSPI_SCK)
G19: J2.4, U1.3 (2A), U2.15 (INPUT3), U5.27 (G19/VSPIMISO)
G21: J2.3, U2.29 (ENABLE1), U5.25 (G21)
G22: J2.1, U1.1 (1A), U2.30 (INPUT1), U5.22 (G22)
G23: SD3.7 (STEP), U5.21 (G23/VPSIMOSI)
G25: SD3.8 (DIR), U5.9 (G25)
G26: SD2.7 (STEP), U5.10 (G26)
G27: SD2.8 (DIR), U5.11 (G27)
G32: SD1.7 (STEP), U5.7 (G32)
G33: SD1.8 (DIR), U5.8 (G33)
G34: B2.2, R9.1, U5.5 (G34)
G35: B3.2, R8.1, U5.6 (G35)
G36: E11.1, R10.1, U5.3 (G36/SVP)
G39: E11.3, R11.1, U5.4 (G39/SVN)
GND: A12.3, A13.3, B2.1, B3.1, C1.2, C2.2, D2.1 (K), D3.1 (K), D4.1 (K), D7.1 (K), E10.2, E11.2, J1.2, J3.3, J4.3, PW_SW14.2, PW_SW15.2, Q1.3 (S), Q2.3 (S), Q3.3 (S), R2.2, R12.2, R13.2, SD1.10 (GND), SD1.16 (GND), SD2.10 (GND), SD2.16 (GND), SD3.10 (GND), SD3.16 (GND), SW16.2, SW17.2, SW18.2, SW19.2, U1.2 (GND), U2.9 (GND), U2.17 (GND), U2.24 (GND), U2.28 (GND), U2.32 (GND), U3.3 (-V), U4.8 (GND), U4.13 (~OE), U5.14 (GND), U5.20 (GND), U5.26 (GND), VREG1.1 (GND)
unnamed: D1.2, K1.2, Q1.1 (D)
unnamed: D3.2 (A), R4.2
unnamed: D4.2 (A), R5.2
unnamed: D5.2, Q2.1 (D), U6.12 (L-)
unnamed: D6.2, Q3.1 (D), U7.12 (L-)
unnamed: D7.2 (A), R14.2
unnamed: F1.1, R3.2, RV1.1
unnamed: PW_SW14.1, U6.5 (S1_O)
unnamed: PW_SW15.1, U7.5 (S1_O)
unnamed: Q1.2 (G), R1.2, R2.1
unnamed: R3.1, U3.1 (AC_L)
unnamed: S7.1, SD1.14 (1B)
unnamed: S7.2, SD1.13 (1A)
unnamed: S7.3, SD1.12 (2A)
unnamed: S7.4, SD1.11 (2B)
unnamed: S8.1, SD2.14 (1B)
unnamed: S8.2, SD2.13 (1A)
unnamed: S8.3, SD2.12 (2A)
unnamed: S8.4, SD2.11 (2B)
unnamed: S9.1, SD3.14 (1B)
unnamed: S9.2, SD3.13 (1A)
unnamed: S9.3, SD3.12 (2A)
unnamed: S9.4, SD3.11 (2B)
unnamed: SD1.5 (~RESET), SD1.6 (~SLEEP)
unnamed: SD2.5 (~RESET), SD2.6 (~SLEEP)
unnamed: SD3.5 (~RESET), SD3.6 (~SLEEP)
unnamed: SW_V14_3.3.2, SW_V14_5.2, SW_V14_12.2, U6.3 (S1_C), U6.4 (S1_C)
unnamed: SW_V15_3.3.2, SW_V15_5.2, SW_V15_12.2, U7.3 (S1_C), U7.4 (S1_C)
PWM1_1: PWM5.1, U2.31 (OUTPUT1)
PWM1_2: PWM5.2, U2.10 (OUTPUT2)
PWM2_1: PWM6.1, U2.16 (OUTPUT3)
PWM2_2: PWM6.2, U2.25 (OUTPUT4)
QA: R1.1, U4.15 (QA)
QB: Q2.2 (G), R12.1, U4.1 (QB)
QC: Q3.2 (G), R13.1, U4.2 (QC)
QD: SW16.1, U4.3 (QD)
QE: SW17.1, U4.4 (QE)
QF: SW18.1, U4.5 (QF)
QG: SW19.1, U4.6 (QG)
QH: R14.1, U4.7 (QH)
~G19: J2.5, U1.4 (2Y), U2.26 (INPUT4)
~G22: J2.2, U1.6 (1Y), U2.11 (INPUT2)

Board: 2 copper layers, 100.0 x 100.0 mm, 67 parts (16 on the bottom side), 70 nets.

## Commit log

2021-11-02 Got tcp data from esp32 using telnet
2021-11-02 Deleted uneeded file
2021-11-03 Did nothing
2021-11-10 more
2021-11-10 Made tcp connections work well
2021-11-16 Did some design, and started looking at cpp server
2021-11-16 Added cpp website things
2021-11-17 Got c++ tcp server working
2021-11-17 Added more things
2021-11-17 added some poc stuff for stepper and encoder - Nolan
2021-11-17 added some poc stuff for stepper and encoder
2021-11-18 added messaging queue uml
2021-11-18 Did high level stuff
2021-11-18 made the board diagram
2021-11-30 Started work on the message structure
2021-11-30 Started project structure and continued making the mesage classes
2021-11-30 working stepper motor code added
2021-12-01 Got the meson build system working decently
2021-12-01 Got the parsing of messages to work
2021-12-01 Messsage system uml
2021-12-02 Tested writing a website with drogon
2021-12-08 The start of the website
2021-12-08 Added the h file
2021-12-12 Started looking at Vue
2021-12-12 This is when vue built to one sinlge html file
2021-12-12 Trying to get vue to work with drogon
2021-12-15 Got vue working with csp filesxy
2021-12-22 Started the actual vue stuff
2021-12-22 Improved the vue changes
2021-12-23 Added more stuff
2021-12-31 Added small things
2022-01-07 Got the database up and running
2022-01-13 Made the website interface with the json database
2022-01-18 Added temp json file so that we can init test systems easy
2022-01-18 Made passing json work
2022-01-18 Testing webhook
2022-01-18 Test the webhook
2022-01-18 Made work without json installed
2022-01-19 added button interrupt poc and editted the stepper poc to add a button control point
2022-01-20 Got esp back and forth comms
2022-01-21 Seperation of serializers
2022-01-21 Started writing the hex serializer
2022-01-23 Made the serializer work
2022-01-23 added working pwm file, button interrupt, encoder example, and reading analog signal
2022-01-23 Made the arduino and server projects compile into one.
    Made the hex serializer work perfectly.
    Made a static map implementation so that we can use the same structure on arduino and server
2022-01-25 Cleaned up the message id stuff
2022-01-25 Added subscriber interface
2022-01-26 Cleaned up dir issues
2022-01-26 Added new sub methods
2022-01-26 Made protected
2022-01-26 Made list viable
2022-01-26 started working on device classes
2022-01-27 Added publisher interface
2022-01-27 Made device interface
2022-01-27 Added virtua
2022-02-01 added a better stepper example that uses the Stepper.h lib
2022-02-01 Made webserver work, and fixed message id / map impl
2022-02-01 Made list work, but is less effecient
2022-02-01 Router
2022-02-02 Got comms between server and esp
2022-02-03 Almost got my singleton working
2022-02-03 continued work on message classes
2022-02-03 Arduino esp wifi receiver
2022-02-03 Created more message classes
2022-02-03 Made buffer for message
2022-02-05 Started replacing the Message class
2022-02-05 Rework of msg system
2022-02-06 Made it work
2022-02-07 kept saying to commit, couldn't pull
2022-02-08 iDid stuff
2022-02-08 Router testing
2022-02-08 it compiles now
2022-02-08 Encoder, Pwm, and Stepper Messages are compiling
2022-02-08 All Message classes compiling
2022-02-08 Got message parsing and stuff with the website
2022-02-08 Pwm Device class hopefully maybe working
2022-02-09 Got website working with esp
2022-02-09 got some device classes going
2022-02-10 circuit
    added circuit
2022-02-10 parts list
    Parts list for circuit
2022-02-10 Did the stuff
2022-02-10 updated Bjt and footprints
2022-02-10 updated footprints
2022-02-11 connected power supply?
2022-02-11 push it baby
2022-02-13 updated some footprints n shit
2022-02-15 made some fun changes
2022-02-15 stepper device class compiling and working on button device
2022-02-15 pushing changes from other laptop
2022-02-16 Button Class hopefully testable
2022-02-16 Encoder Device class created and I believe it compiles as well
2022-02-16 whoops, had to make a little change
2022-02-16 Start of changes
2022-02-16 Analog device class also created
2022-02-16 added filter to Analog Device class
2022-02-17 circuit update
2022-02-17 added symbols and footprints
2022-02-17 Update to Circuit
2022-02-17 made changes to encoder device
2022-02-17 maybe changed stuff
2022-02-17 Edit button class
2022-02-17 button device changes
2022-02-18 pcb progress
2022-02-18 morr PCB progress
2022-02-18 m0r circuit progress
2022-02-18 Started capabilities list thing, deleted copied folder from code
2022-02-21 Device classes compiling except ButtonDevice
2022-02-21 Almost done with list
2022-02-21 Device Classes all compiling
2022-02-21 adding minorId
2022-02-21 Cleaned up various classes
2022-02-22 compiling all devices with minor ids
2022-02-22 Did the thing
2022-02-22 some pcb changes, more are coming tonight
2022-02-22 lots of shit
2022-02-22 Timed publisher
2022-02-22 Added thing
2022-02-22 have an erorr while running
2022-02-22 added 12 plug for power supplys
2022-02-23 "finalized" the grounding stuff fixed more connections. Relay and Screw terminal still needs to be done. I should be able to finish it tonight
2022-02-23 one trace left baby!!
2022-02-23 Stuff
2022-02-23 Did stuff
2022-02-23 encoder device changd
2022-02-23 forgot to save before commmit lol
2022-02-23 finished pcb and generated gerber and drill files
2022-02-23 Fixed the static queue and got other things
2022-02-23 working on testing devices
2022-02-23 Fixed dum issue
2022-02-23 Got the things working?
2022-02-24 Got dynamic init done
2022-02-24 changed stepper driver pinout
2022-02-24 Added const
2022-02-24 iAdded
2022-02-24 actually finished test PCB
2022-02-24 got all device classes except stepper working
2022-02-24 Did more
2022-02-24 finished test PCB frfr
2022-02-25 Did more for website
2022-02-25 all device classes are functional, still working on them, but they are functional
2022-02-25 iWebsite updates dynamically
2022-02-25 Merge
2022-02-26 Slightly changed messages so that things work
2022-02-26 got website dynamic init done
    there is an issue with the server. it sends an empty string first, then
    after sending the next, it sends the previous to the esp
2022-03-03 Added stuff
2022-03-03 added stencil pdf
2022-03-03 stencil stuffff
2022-03-03 sten
2022-03-05 Added file
2022-03-18 Made the queues copy data via buffers so that we have no issue
2022-03-22 Made list iterable
2022-03-22 made some additions for stepper
2022-03-22 Router functions
2022-03-22 Did lots
2022-03-24 Other router tfunctions test
2022-03-24 stencil
2022-03-24 Unsubcribies
2022-03-24 all device classes are functional, need to test with website
2022-03-24 made some more changes to CapabilitiesList.cpp
2022-03-25 all of the sudden my esp is crashing, not sure if code or esp
2022-03-25 trying to debug crashes
2022-03-28 I think this should merge my changes
2022-03-28 forgot one file
2022-03-30 Updated circ w/ dev board
2022-03-31 Finished logic circit
2022-03-31 iMore
2022-03-31 Almost done with messages
2022-03-31 circ update
2022-03-31 relay circuit
2022-04-01 new project
2022-04-01 merging with caden
2022-04-01 Clean
2022-04-01 Close
2022-04-01 added some footprints
2022-04-02 I think the schem is done
2022-04-02 added footprint list to excel and added power supply footprint
2022-04-02 yeah daddy
2022-04-02 Added more
2022-04-02 All assigned
2022-04-02 Done
2022-04-02 Fixed esp
2022-04-02 3.3 now exists
2022-04-02 degen baby
2022-04-12 The gerber files
2022-04-12 added revolver and plate models
2022-04-19 Create stuff
2022-04-19 added new revolver model
2022-04-19 added new bottom plate 2
2022-04-21 Did things
2022-04-21 Did this thing
2022-04-21 added new clamping mechanism sldprts and dxfs
2022-04-22 Did stuff to make it work
2022-04-22 Started task creation
2022-04-22 added double bolt clamp shit
2022-04-23 added stls
2022-04-23 fixed bolt and gear that goes on bolt
2022-04-23 added
2022-04-23 Got alot done
2022-04-23 Tasks now work
2022-04-24 Lots of things work now
2022-04-24 fixed test bolt hopefully
2022-04-25 Maybe I am close?
2022-04-26 Made the timer work
2022-04-26 Fixed the timed events
2022-04-29 This is new code
2022-04-30 Made button debounce
2022-04-30 Did some things
2022-05-02 Added new stuff
2022-05-02 Did a thing
2022-05-02 fixed plate
2022-05-02 Fixed some things
2022-05-02 Made more changes
2022-05-03 made new mains face plate
2022-05-03 This is done
2022-05-04 Case model

Notices in the files:
parts and their libraries:
Copyright 2021 Accelerated Designs. All rights reserved.
Copyright 2016 Accelerated Designs. All rights reserved.
